# Repository Bed-Of-Nails-Test-Fixture-Senior-Design/Hardware

File README.md:

## HARDWARE - BED OF NAILS TEST FIXTURE
In order to have all the library dependencies resolved, you may have to clone the following library: https://github.com/waltoncade/ComLib

BOM: https://docs.google.com/spreadsheets/d/1WrwzJUxgYZxQ-m_5U3LW8MFK-BtWamYw5t6W2Ptqv70/edit?usp=sharing

## KiCad design KiCAD/Interface_Board/Daniel's first attempt.kicad_pcb

Parts:
+12V1: POWER; TestPoint_Plated_Hole_D2.0mm
CCW-D1: Drive CCW; TestPoint_Plated_Hole_D2.0mm
CCW-T1: Tone CCW; TestPoint_Plated_Hole_D2.0mm
CCW-V1: Volume CCW; TestPoint_Plated_Hole_D2.0mm
CW-D1: DRIVE CW; TestPoint_Plated_Hole_D2.0mm
CW-T1: Tone CW; TestPoint_Plated_Hole_D2.0mm
CW-V1: Volume CW; TestPoint_Plated_Hole_D2.0mm
GNDP1: GND; TestPoint_Plated_Hole_D2.0mm
H4, H5, H6, H7: GND; MountingHole_3.7mm_Pad_Via
J1: TB001-500-04BE; TB00150004BE; Manufacturer_Part_Number TB001-500-04BE; Mouser Part Number 490-TB001-500-04BE
J2: Conn_02x15_Top_Bottom; PinSocket_2x15_P2.54mm_Vertical
PresenceIN1: Presence In; TestPoint_Plated_Hole_D2.0mm
PresenceOut1: Presence out; TestPoint_Plated_Hole_D2.0mm
TP1-GND1, TP2-GND1: GND; TestPoint_Plated_Hole_D2.0mm
TP3-12V1: 12V; TestPoint_Plated_Hole_D2.0mm
TP4-PreampOut1: Preamp Out; TestPoint_Plated_Hole_D2.0mm
TP5-8Vout1: TestPoint; TestPoint_Plated_Hole_D2.0mm
TP6-GainStageOut1: Gain Stage Out; TestPoint_Plated_Hole_D2.0mm
TP7-EmitterBypassOut1: Emitter Bypass Out; TestPoint_Plated_Hole_D2.0mm
TP8-6Vout1: 6V Out; TestPoint_Plated_Hole_D2.0mm
TP9-NegDriverOut1: Neg Driver Out; TestPoint_Plated_Hole_D2.0mm
TP10-EmitterFollowerOut1: Emitter Follower Out; TestPoint_Plated_Hole_D2.0mm
TP11-PosDriverOut1: Pos Driver Out; TestPoint_Plated_Hole_D2.0mm
TP13-SourceFollowerOut1: Source Follower Out; TestPoint_Plated_Hole_D2.0mm
TP14-SPKR-1: SPKRNEG; TestPoint_Plated_Hole_D2.0mm
TP16-AuxIN1: AUX R; TestPoint_Plated_Hole_D2.0mm
TP17-GuitarIn1: Guitar In; TestPoint_Plated_Hole_D2.0mm
Tp12-SPKR+1: SPKRPOS; TestPoint_Plated_Hole_D2.0mm
W-D1: Drive W; TestPoint_Plated_Hole_D2.0mm
W-T1: Tone W; TestPoint_Plated_Hole_D2.0mm
W-V1: Volume W; TestPoint_Plated_Hole_D2.0mm

Connections:
6VOut: J2.9, TP8-6Vout1.1
8VOut: J2.10, TP5-8Vout1.1
12VDC: J2.7, TP3-12V1.1
+12V: +12V1.1, J1.3
AUXR: J2.1, TP16-AuxIN1.1
DRIVECCW: CCW-D1.1, J2.15
DRIVECW: CW-D1.1, J2.17
DRIVEW: J2.18, W-D1.1
EmitterBypassOut: J2.6, TP7-EmitterBypassOut1.1
EmitterFollowerOut: J2.5, TP10-EmitterFollowerOut1.1
GND: GNDP1.1, H4.1, H5.1, H6.1, H7.1, J1.4, TP1-GND1.1, TP2-GND1.1
GainStageOut: J2.3, TP6-GainStageOut1.1
GuitarIn: J2.2, TP17-GuitarIn1.1
NEGDriverOut: J2.12, TP9-NegDriverOut1.1
POSDriverOut: J2.11, TP11-PosDriverOut1.1
PreampOut: J2.4, TP4-PreampOut1.1
PresenceIn: J2.26, PresenceIN1.1
PresenceOUT: J2.25, PresenceOut1.1
SourceFollowerOut: J2.8, TP13-SourceFollowerOut1.1
Speaker+: J1.1, Tp12-SPKR+1.1
Speaker-: J1.2, TP14-SPKR-1.1
TONECCW: CCW-T1.1, J2.20
TONECW: CW-T1.1, J2.22
TONEW: J2.19, W-T1.1
VOLUMECCW: CCW-V1.1, J2.21
VolumeCW: CW-V1.1, J2.23
VolumeW: J2.24, W-V1.1

Notes on the sheet:
Note: Some Test Points will not be used
I believe Presence out is GND on Dorrs file
I dont have anything about Pilot.
Make sure diameter of TP is 1.75mm
Make sure TP16 and TP17 are used appropriately
The points need to be mirrored with respect to the test board as we will be connecting from the bsckside

Board: 2 copper layers, 200.7 x 92.2 mm, 35 parts (0 on the bottom side), 27 nets.

## KiCad design KiCAD/Pancake/Pancake.kicad_pcb

Parts:
C5, C6: 220nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C101: 220nF; CP_Radial_D16.0mm_P7.50mm
IC3: LF347N; DIP794W56P254L1905H533Q14N; Manufacturer_Part_Number LF347N; Mouser Part Number 595-LF347N
J1, J2, J3, J4, J5: Conn_01x08_Male; PinHeader_1x08_P2.54mm_Vertical
J7: Conn_02x15_Top_Bottom; PinSocket_2x15_P2.54mm_Vertical
J101: TB001-500-04BE; TB00150004BE; Manufacturer_Part_Number TB001-500-04BE; Mouser Part Number 490-TB001-500-04BE
J102: TB001-500-03BE; TB00150003BE; Manufacturer_Part_Number TB001-500-03BE; Mouser Part Number 490-TB001-500-03BE
LED1: 150120GS75000; LED_1206_3216Metric; Manufacturer_Part_Number 150120GS75000; Mouser Part Number 710-150120GS75000
R1, R2, R7, R8, R18, R19, R20, R21, R22: 91k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3, R4, R13, R14, R24, R25, R26, R27, R28: 33k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6, R9, R10, R17: 68k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11, R12, R15, R16, R23: 39k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R85, R86: 10; R_Axial_Power_L48.0mm_W12.5mm_P55.88mm
R87: 500; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections:
+3V3: J1.4
+5V: J1.5; also elsewhere on the board
-12V: IC3.11 (VCC-), J102.3; also elsewhere on the board
/6VOut: J7.10, R6.2
/8VOut: J7.9, R20.2
/12VOut: J7.8, R19.2
/ADC0: J2.1; also elsewhere on the board
/ADC1: J2.2; also elsewhere on the board
/ADC01/IN1: R5.1, R11.1; also elsewhere on the board
/ADC01/IN2: R6.1, R12.1; also elsewhere on the board
/ADC2: J2.3; also elsewhere on the board
/ADC3: J2.4; also elsewhere on the board
/ADC4: J2.5; also elsewhere on the board
/ADC5: J2.6; also elsewhere on the board
/ADC6: J2.7; also elsewhere on the board
/ADC7: J2.8; also elsewhere on the board
/ADC8: J3.1; also elsewhere on the board
/ADC9: J3.2; also elsewhere on the board
/ADC10: J3.3; also elsewhere on the board
/ADC11: J3.4; also elsewhere on the board
/ADC23/IN1: R17.1, R23.1; also elsewhere on the board
/ADC23/IN2: R18.1, R24.1; also elsewhere on the board
/ADC45/IN1: R9.1, R15.1; also elsewhere on the board
/ADC45/IN2: R10.1, R16.1; also elsewhere on the board
/ADC67/IN1: R19.1, R25.1; also elsewhere on the board
/ADC67/IN2: R20.1, R26.1; also elsewhere on the board
/ADC89/IN1: R7.1, R13.1; also elsewhere on the board
/ADC89/IN2: R8.1, R14.1; also elsewhere on the board
/ADC1011/IN1: R21.1, R27.1; also elsewhere on the board
/ADC1011/IN2: R22.1, R28.1; also elsewhere on the board
/AuxIn: C6.2, J7.2
/D2: J5.6; also elsewhere on the board
/D3: J5.5; also elsewhere on the board
/D4: J5.4; also elsewhere on the board
/D5: J5.3; also elsewhere on the board
/D6: J5.2; also elsewhere on the board
/D7: J5.1; also elsewhere on the board
/D8: J4.8; also elsewhere on the board
/D9: J4.7; also elsewhere on the board
/D10: J4.6; also elsewhere on the board
/D11: J4.5; also elsewhere on the board
/D12: J4.4; also elsewhere on the board
/DAC1: J3.6, R2.2
/DAC01/IN1: R1.1, R3.1; also elsewhere on the board
/DAC01/IN2: R2.1, R4.1; also elsewhere on the board
/DAC01/OUT1: C5.1; also elsewhere on the board
/DAC01/OUT2: C6.1; also elsewhere on the board
/DAC2: J3.5, R1.2
/DriveCCW: J7.16; also elsewhere on the board
/DriveCW: J7.18; also elsewhere on the board
/DriveMid: J7.17; also elsewhere on the board
/EmitterBypassOut: IC3.10 (3IN+), J7.5
/EmitterFollowerOut: J7.6, R17.2
/GainStageOut: IC3.12 (4IN+), J7.4
/GuitarIn: C5.2, J7.1
/NegDriverOut: J7.11, R8.2
/PosDriverOut: J7.12, R7.2
/PreampOut: J7.3, R5.2
/PresenceIn: J7.25; also elsewhere on the board
/PresenceOut: J7.26; also elsewhere on the board
/SPRKNeg: J101.3, R22.2, R85.1, R86.1
/SPRKPos: C101.1, J101.4, R21.2
/SourceFollowerOut: J7.7, R18.2
/ToneCCW: J7.19; also elsewhere on the board
/ToneCW: J7.21; also elsewhere on the board
/ToneMid: J7.20; also elsewhere on the board
/VolumeCCW: J7.22; also elsewhere on the board
/VolumeCW: J7.24; also elsewhere on the board
/VolumeMid: J7.23; also elsewhere on the board
GND: J1.6, J1.7, J4.2, J101.1, J102.2, LED1.1, R3.2, R4.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2; also elsewhere on the board
unnamed: C101.2, R85.2, R86.2
unnamed: IC3.8 (3OUT), IC3.9 (3IN-), R10.2
unnamed: IC3.13 (4IN-), IC3.14 (4OUT), R9.2

Notes on the sheet:
Arduino Header Pins

Parts:
C67, C68, C74, C76: 680pF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C69, C75: 3.3nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C70, C71, C72, C73: 180pF; C_Disc_D4.3mm_W1.9mm_P5.00mm
IC10: LF347N; DIP794W56P254L1905H533Q14N; Manufacturer_Part_Number LF347N; Mouser Part Number 595-LF347N
R77, R83: 43k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R78, R84: 9.1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R79, R81: 30k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R80, R82: 36k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections:
-12V: IC10.11 (VCC-); also elsewhere on the board
/ADC0: C69.1, IC10.6 (2IN-), IC10.7 (2OUT); also elsewhere on the board
/ADC1: C75.1, IC10.8 (3OUT), IC10.9 (3IN-); also elsewhere on the board
/ADC01/1stage: C68.1, IC10.1 (1OUT), IC10.2 (1IN-), R78.1
/ADC01/2stage: C74.1, IC10.13 (4IN-), IC10.14 (4OUT), R84.1
/ADC01/IN1: C67.2, R77.1; also elsewhere on the board
/ADC01/IN2: C76.2, R83.1; also elsewhere on the board
GND: C67.1, C70.1, C71.2, C72.1, C73.2, C76.1; also elsewhere on the board
unnamed: C68.2, R77.2, R79.1
unnamed: C69.2, R78.2, R80.1
unnamed: C70.2, IC10.3 (1IN+), R79.2
unnamed: C71.1, IC10.5 (2IN+), R80.2
unnamed: C72.2, IC10.12 (4IN+), R81.2
unnamed: C73.1, IC10.10 (3IN+), R82.2
unnamed: C74.2, R81.1, R83.2
unnamed: C75.2, R82.1, R84.2

Parts of its further copies:
C7, C8, C14, C16, C17, C18, C24, C26, C27, C28, C34, C36, C37, C38, C44, C46, C47, C48, C54, C56, C57, C58, C64, C66: 680pF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C9, C15, C19, C25, C29, C35, C39, C45, C49, C55, C59, C65: 3.3nF; C_Disc_D4.3mm_W1.9mm_P5.00mm
C10, C11, C12, C13, C20, C21, C22, C23, C30, C31, C32, C33, C40, C41, C42, C43, C50, C51, C52, C53, C60, C61, C62, C63: 180pF; C_Disc_D4.3mm_W1.9mm_P5.00mm
IC4, IC5, IC6, IC7, IC8, IC9: LF347N; DIP794W56P254L1905H533Q14N; Manufacturer_Part_Number LF347N; Mouser Part Number 595-LF347N
R29, R35, R37, R43, R45, R51, R53, R59, R61, R67, R69, R75: 43k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R30, R36, R38, R44, R46, R52, R54, R60, R62, R68, R70, R76: 9.1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R31, R33, R39, R41, R47, R49, R55, R57, R63, R65, R71, R73: 30k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R32, R34, R40, R42, R48, R50, R56, R58, R64, R66, R72, R74: 36k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections of its further copies:
-12V: IC4.11 (VCC-), IC5.11 (VCC-), IC6.11 (VCC-), IC7.11 (VCC-), IC8.11 (VCC-), IC9.11 (VCC-); also elsewhere on the board
/ADC2: C39.1, IC7.6 (2IN-), IC7.7 (2OUT); also elsewhere on the board
/ADC3: C45.1, IC7.8 (3OUT), IC7.9 (3IN-); also elsewhere on the board
/ADC4: C49.1, IC8.6 (2IN-), IC8.7 (2OUT); also elsewhere on the board
/ADC5: C55.1, IC8.8 (3OUT), IC8.9 (3IN-); also elsewhere on the board
/ADC6: C29.1, IC6.6 (2IN-), IC6.7 (2OUT); also elsewhere on the board
/ADC7: C35.1, IC6.8 (3OUT), IC6.9 (3IN-); also elsewhere on the board
/ADC8: C59.1, IC9.6 (2IN-), IC9.7 (2OUT); also elsewhere on the board
/ADC9: C65.1, IC9.8 (3OUT), IC9.9 (3IN-); also elsewhere on the board
/ADC10: C19.1, IC5.6 (2IN-), IC5.7 (2OUT); also elsewhere on the board
/ADC11: C25.1, IC5.8 (3OUT), IC5.9 (3IN-); also elsewhere on the board
/ADC23/1stage: C38.1, IC7.1 (1OUT), IC7.2 (1IN-), R54.1
/ADC23/2stage: C44.1, IC7.13 (4IN-), IC7.14 (4OUT), R60.1
/ADC23/IN1: C37.2, R53.1; also elsewhere on the board
/ADC23/IN2: C46.2, R59.1; also elsewhere on the board
/ADC45/1stage: C48.1, IC8.1 (1OUT), IC8.2 (1IN-), R62.1
/ADC45/2stage: C54.1, IC8.13 (4IN-), IC8.14 (4OUT), R68.1
/ADC45/IN1: C47.2, R61.1; also elsewhere on the board
/ADC45/IN2: C56.2, R67.1; also elsewhere on the board
/ADC67/1stage: C28.1, IC6.1 (1OUT), IC6.2 (1IN-), R46.1
/ADC67/2stage: C34.1, IC6.13 (4IN-), IC6.14 (4OUT), R52.1
/ADC67/IN1: C27.2, R45.1; also elsewhere on the board
/ADC67/IN2: C36.2, R51.1; also elsewhere on the board
/ADC89/1stage: C58.1, IC9.1 (1OUT), IC9.2 (1IN-), R70.1
/ADC89/2stage: C64.1, IC9.13 (4IN-), IC9.14 (4OUT), R76.1
/ADC89/IN1: C57.2, R69.1; also elsewhere on the board
/ADC89/IN2: C66.2, R75.1; also elsewhere on the board
/ADC1011/1stage: C18.1, IC5.1 (1OUT), IC5.2 (1IN-), R38.1
/ADC1011/2stage: C24.1, IC5.13 (4IN-), IC5.14 (4OUT), R44.1
/ADC1011/IN1: C17.2, R37.1; also elsewhere on the board
/ADC1011/IN2: C26.2, R43.1; also elsewhere on the board
/DAC01/1stage: C8.1, IC4.1 (1OUT), IC4.2 (1IN-), R30.1
/DAC01/2stage: C14.1, IC4.13 (4IN-), IC4.14 (4OUT), R36.1
/DAC01/IN1: C7.2, R29.1; also elsewhere on the board
/DAC01/IN2: C16.2, R35.1; also elsewhere on the board
/DAC01/OUT1: C9.1, IC4.6 (2IN-), IC4.7 (2OUT); also elsewhere on the board
/DAC01/OUT2: C15.1, IC4.8 (3OUT), IC4.9 (3IN-); also elsewhere on the board
GND: C7.1, C10.1, C11.2, C12.1, C13.2, C16.1, C17.1, C20.1, C21.2, C22.1, C23.2, C26.1, C27.1, C30.1, C31.2, C32.1, C33.2, C36.1, C37.1, C40.1, C41.2, C42.1, C43.2, C46.1, C47.1, C50.1, C51.2, C52.1, C53.2, C56.1, C57.1, C60.1, C61.2, C62.1, C63.2, C66.1; also elsewhere on the board
unnamed: C8.2, R29.2, R31.1
unnamed: C9.2, R30.2, R32.1
unnamed: C10.2, IC4.3 (1IN+), R31.2
unnamed: C11.1, IC4.5 (2IN+), R32.2
unnamed: C12.2, IC4.12 (4IN+), R33.2
unnamed: C13.1, IC4.10 (3IN+), R34.2
unnamed: C14.2, R33.1, R35.2
unnamed: C15.2, R34.1, R36.2
unnamed: C18.2, R37.2, R39.1
unnamed: C19.2, R38.2, R40.1
unnamed: C20.2, IC5.3 (1IN+), R39.2
unnamed: C21.1, IC5.5 (2IN+), R40.2
unnamed: C22.2, IC5.12 (4IN+), R41.2
unnamed: C23.1, IC5.10 (3IN+), R42.2
unnamed: C24.2, R41.1, R43.2
unnamed: C25.2, R42.1, R44.2
unnamed: C28.2, R45.2, R47.1
unnamed: C29.2, R46.2, R48.1
unnamed: C30.2, IC6.3 (1IN+), R47.2
unnamed: C31.1, IC6.5 (2IN+), R48.2
unnamed: C32.2, IC6.12 (4IN+), R49.2
unnamed: C33.1, IC6.10 (3IN+), R50.2
unnamed: C34.2, R49.1, R51.2
unnamed: C35.2, R50.1, R52.2
unnamed: C38.2, R53.2, R55.1
unnamed: C39.2, R54.2, R56.1
unnamed: C40.2, IC7.3 (1IN+), R55.2
unnamed: C41.1, IC7.5 (2IN+), R56.2
unnamed: C42.2, IC7.12 (4IN+), R57.2
unnamed: C43.1, IC7.10 (3IN+), R58.2
unnamed: C44.2, R57.1, R59.2
unnamed: C45.2, R58.1, R60.2
unnamed: C48.2, R61.2, R63.1
unnamed: C49.2, R62.2, R64.1
unnamed: C50.2, IC8.3 (1IN+), R63.2
unnamed: C51.1, IC8.5 (2IN+), R64.2
unnamed: C52.2, IC8.12 (4IN+), R65.2
unnamed: C53.1, IC8.10 (3IN+), R66.2
unnamed: C54.2, R65.1, R67.2
unnamed: C55.2, R66.1, R68.2
unnamed: C58.2, R69.2, R71.1
unnamed: C59.2, R70.2, R72.1
unnamed: C60.2, IC9.3 (1IN+), R71.2
unnamed: C61.1, IC9.5 (2IN+), R72.2
unnamed: C62.2, IC9.12 (4IN+), R73.2
unnamed: C63.1, IC9.10 (3IN+), R74.2
unnamed: C64.2, R73.1, R75.2
unnamed: C65.2, R74.1, R76.2

Notes on the sheet:
1st pole
2nd and 3rd poles
4th and 5th poles

Parts:
Q901, Q902: ULN2003AIN; DIP794W53P254L1930H508Q16N; Manufacturer_Part_Number ULN2003AIN; Mouser Part Number 595-ULN2003AIN
R901, R902, R903, R904, R905, R906: 50K; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RelayA901: 833H-1A-F-S-12VDC; 833H1AFS12VDC
RelayB901: 833H-1A-F-S-12VDC; 833H1AFS12VDC
RelayC901: 833H-1A-F-S-12VDC; 833H1AFS12VDC
RelayD901: 833H-1A-F-S-12VDC; 833H1AFS12VDC
RelayE901: 833H-1A-F-S-12VDC; 833H1AFS12VDC
RelayF901: 833H-1A-F-S-12VDC; 833H1AFS12VDC
RelayG901: 833H-1A-F-S-12VDC; 833H1AFS12VDC
RelayH901: 833H-1A-F-S-12VDC; 833H1AFS12VDC
RelayI901: 833H-1A-F-S-12VDC; 833H1AFS12VDC
RelayJ901: 833H-1A-F-S-12VDC; 833H1AFS12VDC

Connections:
/D2: Q902.1 (1B); also elsewhere on the board
/D3: Q902.2 (2B); also elsewhere on the board
/D4: Q902.3 (3B); also elsewhere on the board
/D5: Q902.4 (4B); also elsewhere on the board
/D6: Q901.1 (1B); also elsewhere on the board
/D7: Q901.2 (2B); also elsewhere on the board
/D8: Q901.3 (3B); also elsewhere on the board
/D9: Q901.4 (4B); also elsewhere on the board
/D10: Q901.5 (5B); also elsewhere on the board
/D11: Q901.6 (6B); also elsewhere on the board
/DriveCCW: R904.2, RelayJ901.3 (NO); also elsewhere on the board
/DriveCW: R903.1, RelayH901.3 (NO); also elsewhere on the board
/DriveMid: RelayH901.1 (COM), RelayI901.1 (COM), RelayJ901.1 (COM); also elsewhere on the board
/PresenceIn: RelayA901.3 (NO); also elsewhere on the board
/PresenceOut: RelayA901.1 (COM); also elsewhere on the board
/ToneCCW: R902.2, RelayG901.3 (NO); also elsewhere on the board
/ToneCW: R901.1, RelayE901.3 (NO); also elsewhere on the board
/ToneMid: RelayE901.1 (COM), RelayF901.1 (COM), RelayG901.1 (COM); also elsewhere on the board
/VolumeCCW: R906.2, RelayD901.3 (NO); also elsewhere on the board
/VolumeCW: R905.1, RelayB901.3 (NO); also elsewhere on the board
/VolumeMid: RelayB901.1 (COM), RelayC901.1 (COM), RelayD901.1 (COM); also elsewhere on the board
GND: Q901.8 (E), Q902.8 (E); also elsewhere on the board
unnamed: Q901.11 (6C), RelayJ901.5 (COIL_2)
unnamed: Q901.12 (5C), RelayI901.5 (COIL_2)
unnamed: Q901.13 (4C), RelayH901.5 (COIL_2)
unnamed: Q901.14 (3C), RelayG901.5 (COIL_2)
unnamed: Q901.15 (2C), RelayF901.5 (COIL_2)
unnamed: Q901.16 (1C), RelayE901.5 (COIL_2)
unnamed: Q902.13 (4C), RelayD901.5 (COIL_2)
unnamed: Q902.14 (3C), RelayC901.5 (COIL_2)
unnamed: Q902.15 (2C), RelayB901.5 (COIL_2)
unnamed: Q902.16 (1C), RelayA901.5 (COIL_2)
unnamed: R901.2, R902.1, RelayF901.3 (NO)
unnamed: R903.2, R904.1, RelayI901.3 (NO)
unnamed: R905.2, R906.1, RelayC901.3 (NO)

Notes on the sheet:
P(OUT/IN)
VOL(CW/MID/CCW)
TONE(CW/MID/CCW)
DRIVE(CW/MID/CCW)

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
Board: 2 copper layers, 215.9 x 142.2 mm, 202 parts (5 on the bottom side), 158 nets.

Other parts of the board:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.5mm_Pad_Via
LED2: 150120GS75000; LEDC3214X78N
R88: 150; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
R89: 1000; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder

Their connections:
+5V: R88.2; also elsewhere on the board
/D12: LED2.1; also elsewhere on the board
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board
unnamed: LED2.2, R88.1
