# Repository Bed-Of-Nails-Test-Fixture-Senior-Design/Hardware (continued)

## KiCad design mini_project/Board/KiCAD Schematic and PCB - Quick Design Example and Build.kicad_pcb

Parts:
C1, C2: 1micro; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.5mm_Pad_Via
J1, J13: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J2, J3: Conn_01x01; PinSocket_1x01_P2.54mm_Vertical
J4, J5, J6, J7, J8, J9, J10: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
J11, J12: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
R1: 150k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2, R4, R13: 62k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R3: 56k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R6: 68k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7: 160k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8, R9, R10: 1M; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R11: 16k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R12: 20k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R14: 36k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R15: 52k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R16: 13k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R17: 820; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R18: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R20: 1.8k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R21: 6.98k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1: 100k; Potentiometer_Bourns_3386P_Vertical
U1: LM339; DIP-14_W7.62mm_LongPads
U5: NA555P; DIP-8_W7.62mm_LongPads

Connections:
1out: J1.3, R10.1, R15.1, R16.2, U1.13
3out: J1.2, R9.1, R13.1, R14.2, U1.1
5out: J1.1, R8.1, R11.1, R12.2, U1.2
+9V: C2.2, J2.1, R1.1, R11.2, R13.2, R15.2, R18.1, U1.3 (V+), U5.4 (R), U5.8 (VCC)
GND: C1.2, C2.1, H1.1, H2.1, H3.1, H4.1, J3.1, J13.1, J13.2, J13.3, R4.2, R12.1, R14.1, R16.1, R21.2, U1.12 (V-), U5.1 (GND)
unnamed: C1.1, R17.2, RV1.3, U5.2 (TR), U5.6 (THR)
unnamed: J5.1, R3.2, R4.1, U1.10 (-)
unnamed: J6.1, R7.1, R10.2, U1.11 (+)
unnamed: J7.1, R2.2, R3.1, U1.6 (-)
unnamed: J8.1, R6.1, R9.2, U1.7 (+)
unnamed: J9.1, R1.2, R2.1, U1.4 (-)
unnamed: J10.1, R5.1, R8.2, U1.5 (+)
unnamed: J11.2, R20.2, R21.1
unnamed: J12.1, R18.2, RV1.2, U5.7 (DIS)
unnamed: J12.2, R17.1
unnamed: R20.1, U5.3 (Q)
Tsig: J4.1, J11.1, R5.2, R6.2, R7.2

Board: 2 copper layers, 112.6 x 72.2 mm, 42 parts (0 on the bottom side), 17 nets.

## Commit log

2021-02-22 Hysteresis Circuit finished!
2021-02-23 Circuit design finished!
2021-03-12 Finished mini-project
2021-04-14 Block Diagram Iterations
2021-04-14 Reorganizing
2021-04-20 Cleaning up directory structure and adding firmware schematic
2021-06-22 Final commit of first semester
2021-06-22 Initial Fall Commit
2021-06-22 Cleaned up fall directory
2021-07-27 KiCAD PCB started, LTSpice analog filter simulation complete
2021-08-27 All input filters/attenuators modeled and tested in ltspice
2021-08-27 Extra kicad stuff
2021-08-31 12v5
2021-08-31 dope
2021-09-01 LTspice models
2021-09-01 DAC Filters and Relays
2021-09-02 Re-did filters for 5% resistors
2021-09-02 Schematic almost complete. layout still required
2021-09-02 Ribbon cable connector, arduino layout
2021-09-03 Arduino laid out
2021-09-03 Models
2021-09-08 EDIT WAS MADE, FIND it
2021-09-08 Moved giant component over
2021-09-08 Power resistor sims
2021-09-09 Have a few more filters to align but I believe the current layout can allow us to route.
2021-09-10 Going to get big like Justin. Need to clean up ribbon,as there are a few resistors that run a long ways until their only connection.
2021-09-13 Latest revision
2021-09-13 Lib updates and capacitor add. Simulation on power resistor working
2021-09-13 Changed directory structure
2021-09-13 Doc updates
2021-09-13 Remove library dependency
2021-09-13 removed docs
2021-09-14 Test
2021-09-14 Thiccccc Traces
2021-09-17 The traces is all that is left. we may fall into problems with mark with clearances, we will see.
2021-09-19 LED for connection of power. I was not able to find the footprint for the 1206 SMD LED that is in the Senior design lab, but I was able to find one for a similar model. With that being said, the mode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
2021-09-20 Will need to retrace in order to be built at SDSU.
2021-09-24 Revising one last time before ordering
2021-09-24 Moving trace to keep antenna effect low
2021-09-27 PDF Outputs
2021-09-28 Give it a look, then let blow the horn.
2021-09-29 fills. In checkout when we are ready to send it
2021-11-04 Bless you Thank you
2021-11-04 Reminder: Need to change diameter of TP points from 2.0mm to 1.75mm before sign off
2021-11-05 Zero Vias needed :)!! added vias only for GND if necessary. Note: Since we are plugging in the cable to the bottom of the testboard, the ribbon cable will be flipped therefore, the test points on the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
2021-11-05 Final Rev 1. Sent To mark to mil, hopefully have before End of Day
2021-11-10 Missed one
